# IAR project STM32G0B1_Boot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32G081RB ST STM32G081RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32G0B1xx
  ICCARM.CCIncludePath2: ..; ..\..\Source; ..\lib; ..\lib\CMSIS\Device\ST\STM32G0xx\Include; ..\lib\CMSIS\Include; ..\lib\STM32G0xx_HAL_Driver\Inc; ..\lib\STM32G0xx_HAL_Driver\Inc\Legacy; ..\..\Source\ARMCM0_STM32G0; ..\USB_Device\App; ..\USB_Device\Target; ..\lib\STM32_USB_Device_Library\Class\CDC\Inc; ..\lib\STM32_USB_Device_Library\Core\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32G0B1_Boot.srec
  ILINK.IlinkOutputFile: STM32G0B1_Boot.out
  ILINK.IlinkIcfFile: F:\OpenBLT_Crypt_Release\STM32G0-OpenBLT-USB-CDC\General_Boot\stm32g0b1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Boot
    ../: blt_conf.h flash_layout.c hooks.c led.c main.c startup_stm32g0b1xx.s
  group Boot/Lib
    ../lib/: stm32g0xx_hal_conf.h system_stm32g0xx.c
  group Boot/Lib/HAL
    ../lib/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_fdcan.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_pcd.c stm32g0xx_hal_pcd_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_ll_crs.c stm32g0xx_ll_dma.c stm32g0xx_ll_exti.c stm32g0xx_ll_gpio.c stm32g0xx_ll_rcc.c stm32g0xx_ll_usart.c stm32g0xx_ll_usb.c stm32g0xx_ll_utils.c
  group Source
    ../../Source/: asserts.c backdoor.c boot.c com.c cop.c file.c mb.c net.c xcp.c
  group Source/ARMCM0_STM32G0
    ../../Source/ARMCM0_STM32G0/: can.c cpu.c flash.c mbrtu.c nvm.c rs232.c timer.c
  group Source/ARMCM0_STM32G0/IAR
    ../../Source/ARMCM0_STM32G0/IAR/: cpu_comp.c
  group USB_CDC_POLL
    ../: usb_cdc_poll.c
  group USB_Device/App
    ../USB_Device/App/: usb_device.c usbd_cdc_if.c usbd_desc.c
  group USB_Device/Target
    ../USB_Device/Target/: usbd_conf.c
  group USB_Device_Library/CDC
    ../lib/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group USB_Device_Library/Core
    ../lib/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
